<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Coordinator\Coordinator.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Sensor\Sensor.ewp</path>
  </project>
</workspace>


