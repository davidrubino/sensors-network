# IAR project Sensor.ewp, settings and files
configuration EndDevice (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; FEATURE_GREEN_POWER; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xHOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: -f ..\SDK\Projects\zstack\HomeAutomation\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\SDK\Projects\zstack\HomeAutomation\..\Tools\CC2538DB\f8wEndev.cfg
  ICCARM.CCIncludePath2: Source; ..\Common; ..\SDK\Projects\zstack\HomeAutomation\Source; ..\SDK\Projects\zstack\HomeAutomation\..\Zmain\TI2538DB; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\hal\include; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\hal\target\CC2538; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\driverlib\cc2538\inc; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\driverlib\cc2538\source; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\sdriverlib\cc2538\source; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\mac\include; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\mac\high_level; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\mac\low_level\srf05\single_chip; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\mac\low_level\srf05; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\mt; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\osal\include; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\services\sdata; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\services\saddr; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\stack\af; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\stack\nwk; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\stack\sapi; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\stack\sec; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\stack\sys; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\stack\zdo; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\zmac; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\zmac\f8w
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Application
  OBJCOPY.OOCOutputFile: Sensor.bin
  ILINK.IlinkOutputFile: Sensor.out
  ILINK.IlinkIcfFile: ..\SDK\Projects\zstack\HomeAutomation\..\Tools\CC2538DB\CC2538.icf
  ILINK.IlinkAdditionalLibs: ..\SDK\Projects\zstack\HomeAutomation\..\Libraries\CC2538\bin\EndDevice.a; ..\SDK\Projects\zstack\HomeAutomation\..\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Router (ARM, debug)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f ..\SDK\Projects\zstack\HomeAutomation\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\SDK\Projects\zstack\HomeAutomation\..\Tools\CC2538DB\f8wRouter.cfg
  ILINK.IlinkAdditionalLibs: ..\SDK\Projects\zstack\HomeAutomation\..\Libraries\CC2538\bin\Router.a; ..\SDK\Projects\zstack\HomeAutomation\..\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\SDK\Projects\zstack\HomeAutomation\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  group Application
    Source/: OSAL_Sensor.c Sensor.c Sensor.h
  group Application/Common
    ../Common/: Common.h
  group HAL/Common
    ../SDK/Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../SDK/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/Drivers
    ../SDK/Components/hal/target/CC2538/: hal_adc.c hal_aes.c hal_ccm.c hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.c hal_sleep.c hal_sys_ctrl.c hal_systick.c hal_uart.c startup_ewarm.c
  group HAL/Target/Include
    ../SDK/Components/hal/target/CC2538/: hal_aes.h hal_board_cfg.h hal_ccm.h hal_mac_cfg.h hal_mcu.h hal_sys_ctrl.h hal_systick.h hal_types.h iocc2538.h
  group MAC/High Level
    ../SDK/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../SDK/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../SDK/Components/mac/low_level/srf05/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../SDK/Components/mac/low_level/srf05/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_radio_reg_defs.h mac_rffrontend.c
  group MT
    ../SDK/Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../SDK/Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../SDK/Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../SDK/Components/osal/mcu/cc2538/: armcm3flashutil.c armcm3flashutil.h osal_nv.c
    ../SDK/Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../SDK/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Profile
    ../SDK/Components/stack/af/: AF.c AF.h
  group Security
    ../SDK/Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../SDK/Components/services/saddr/: saddr.c saddr.h
    ../SDK/Components/services/sdata/: sdata.h
  group Tools
    ../SDK/Projects/zstack/Tools/CC2538DB/: CC2538.icf f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../SDK/Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../SDK/Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../SDK/Components/zmac/: ZMAC.h
  group ZMain
    ../SDK/Projects/zstack/ZMain/TI2538DB/: OnBoard.c OnBoard.h ZMain.c
